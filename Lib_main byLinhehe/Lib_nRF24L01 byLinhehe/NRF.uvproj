# Keil uVision project NRF.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NRF
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: NRF24L01.h NRF24L01.c SPI.h sameShit.h SPI.c PINS.h main.c
    ../: sameShit.c
